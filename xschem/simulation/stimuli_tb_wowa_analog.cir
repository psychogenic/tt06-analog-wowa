**************************************
* SPICE STIMULI FILE
* generated from
**************************************

Vvss vss 0 PWL 0n 0
Vinput input 0 PWL 0n 1.2 10040n 1.2 10041n 0.3 19040n 0.3 19041n 1.4 38040n
+1.4 38041n 0.44 58040n 0.44 58041n 1.45 78040n 1.45 78041n 1.1
Ven_n en_n 0 PWL 0n 0
Vvcc vcc 0 PWL 0n VCC
Vextthresh extthresh 0 PWL 0n 0.8
Vuseext useext 0 PWL 0n 0
Vcal cal 0 PWL 0n 0 40n 0 41n VCC 1040n VCC 1041n 0
